# Keil uVision project STM32F103模板固件库.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 4乘4矩阵密码按键 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\CORE;..\..\USER;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\..\STM32F10x_FWLib\inc;..\..\HARDWARE\LED;..\RVMDK（uv5）;..\..\SYSTEM\key;..\..\SYSTEM\KEY4-4;..\..\HARDWARE\AS608;..\..\HARDWARE\MALLOC;..\..\HARDWARE\TIMER;..\..\HARDWARE\USART2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../CORE/: startup_stm32f10x_hd.s
  group STM32F10x_FWLib
    ../../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group SYSTEM
    ../../SYSTEM/delay/: delay.c
    ../../SYSTEM/sys/: sys.c
    ../../SYSTEM/usart/: usart.c
    ../../HARDWARE/LED/: led.c
    ../../SYSTEM/key/: key.c
    ../../SYSTEM/KEY4-4/: key4_4.c
    ../../HARDWARE/AS608/: as608.c
    ../../HARDWARE/MALLOC/: malloc.c
    ../../HARDWARE/TIMER/: timer.c
    ../../HARDWARE/USART2/: usart2.c
  group USER
    ../../USER/: main.c stm32f10x_it.c system_stm32f10x.c
